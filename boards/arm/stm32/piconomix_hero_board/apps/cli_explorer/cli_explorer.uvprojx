# Keil uVision project cli_explorer.uvprojx, settings and files
target piconomix_hero_board (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L072RBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: cli_explorer +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PX_DBG=0,STM32L072xx, USE_FULL_LL_DRIVER
  c misc: --C99 --gnu
  c include: cfg;res;src;..\..\..\..\..\..\boards\arm\stm32\piconomix_hero_board;..\..\..\..\..\..\arch\arm\stm32;..\..\..\..\..\..\common;..\..\..\..\..\..\comms;..\..\..\..\..\..\devices\display;..\..\..\..\..\..\devices\mem;..\..\..\..\..\..\gfx;..\..\..\..\..\..\gfx\fonts;..\..\..\..\..\..\gfx\images;..\..\..\..\..\..\utils;..\..\..\..\..\..\libs\STM32Cube\L0\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\libs\STM32Cube\L0\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\..\libs\STM32Cube\L0\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\libs\STM32Cube\L0\Drivers\CMSIS\Include;..\..\..\..\..\..\libs\STM32Cube_USB\Class\CDC\Inc;..\..\..\..\..\..\libs\STM32Cube_USB\Core\Inc;..\..\..\..\..\..\libs\ChaN_FatFs
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cfg
    ./cfg/: ffconf.h px_cli_cfg.h px_dbg_cfg.h px_gfx_cfg.h px_i2c_cfg.h px_rtc_cfg.h px_spi_cfg.h px_sysclk_cfg.h px_uart_cfg.h px_xmodem_cfg.h stm32l0xx_hal_conf.h px_rtc_util_cfg.h px_adc_cfg.h px_at25s_cfg.h px_dac_cfg.h px_lcd_st7567_jhd12864_cfg.h
  group res
    ./res/: px_gfx_res.h
  group src
    ./src/: main.c main.h px_cli_cmds.c px_cli_cmds_gpio.c px_cli_cmds_gpio.h px_cli_cmds_i2c.c px_cli_cmds_i2c.h px_cli_cmds_lcd.c px_cli_cmds_lcd.h px_cli_cmds_mem.c px_cli_cmds_mem.h px_cli_cmds_rtc.c px_cli_cmds_rtc.h px_cli_cmds_sd.c px_cli_cmds_sd.h px_cli_cmds_sf.c px_cli_cmds_sf.h px_cli_cmds_spi.c px_cli_cmds_spi.h px_cli_cmds_uart.c px_cli_cmds_uart.h px_sd_fatfs_diskio.c px_xmodem_glue.c px_xmodem_glue.h stm32l0xx_it.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c px_cli_cmds_adc.h usb_device.h usbd_cdc_if.h usbd_conf.h usbd_desc.h px_cli_cmds_adc.c px_cli_cmds_dac.c px_cli_cmds_dac.h
  group lib/piconomix-fwlib
    ../../: px_board.c
    ../../../../../../arch/arm/stm32/: px_gpio.c px_i2c.c px_spi.c px_sysclk.c px_uart.c px_usb_cdc_stdio.c px_rtc.c px_adc.c px_dac.c
    ../../../../../../comms/: px_cli.c px_vt100.c px_xmodem.c
    ../../../../../../devices/mem/: px_sd.c px_at25s.c
    ../../../../../../gfx/: px_gfx.c
    ../../../../../../gfx/fonts/: px_gfx_font_5x7.c
    ../../../../../../gfx/images/: px_gfx_img_hero_logo_64x42.c
    ../../../../../../utils/: px_circ_buffer.c px_dbg.c px_systmr.c px_rtc_util.c
    ../../../../../../devices/display/: px_lcd_st7567_jhd12864.c
  group STM32Cube/Drivers/CMSIS
    ../../../../../../libs/STM32Cube/L0/Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
    ../../../../../../libs/STM32Cube/L0/Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l072xx.s
  group STM32Cube/Drivers/HAL_Driver
    ../../../../../../libs/STM32Cube/L0/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_utils.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_ll_usb.c
  group STM32Cube_USB/Class
    ../../../../../../libs/STM32Cube_USB/Class/CDC/Src/: usbd_cdc.c
  group STM32Cube_USB/Core
    ../../../../../../libs/STM32Cube_USB/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group lib/ChaN_FatFs
    ../../../../../../libs/ChaN_FatFs/: ff.c
