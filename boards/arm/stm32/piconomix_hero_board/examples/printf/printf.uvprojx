# Keil uVision project printf.uvprojx, settings and files
target piconomix_hero_board (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L072RBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: printf +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L072xx, USE_FULL_LL_DRIVER
  c misc: --C99 --gnu
  c include: cfg; src; ../../../../../../boards/arm/stm32/piconomix_hero_board; ../../../../../../arch/arm/stm32; ../../../../../../common; ../../../../../../utils; ../../../../../../libs/STM32Cube/L0/Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../libs/STM32Cube/L0/Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../../../../../../libs/STM32Cube/L0/Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../libs/STM32Cube/L0/Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cfg
    ./cfg/: px_dbg_cfg.h px_uart_cfg.h px_sysclk_cfg.h stm32l0xx_hal_conf.h
  group src
    ./src/: main.h main.c
  group lib/piconomix-fwlib
    ../../: px_board.h px_board.c
    ../../../../../../utils/: px_circ_buffer.h px_circ_buffer.c
    ../../../../../../arch/arm/stm32/: px_gpio.h px_gpio.c px_uart.c px_uart.h px_uart_stdio.c px_uart_stdio.h
  group STM32Cube/Drivers/CMSIS
    ../../../../../../libs/STM32Cube/L0/Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l072xx.s
    ../../../../../../libs/STM32Cube/L0/Drivers/CMSIS/Device/ST/STM32L0xx/Include/: stm32l0xx.h stm32l072xx.h system_stm32l0xx.h
    ../../../../../../libs/STM32Cube/L0/Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group STM32Cube/Drivers/HAL_Driver
    ../../../../../../libs/STM32Cube/L0/Drivers/STM32L0xx_HAL_Driver/Inc/: stm32l0xx_ll_bus.h stm32l0xx_ll_cortex.h stm32l0xx_ll_gpio.h stm32l0xx_ll_pwr.h stm32l0xx_ll_rcc.h stm32l0xx_ll_system.h stm32l0xx_ll_utils.h
    ../../../../../../libs/STM32Cube/L0/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_utils.c
