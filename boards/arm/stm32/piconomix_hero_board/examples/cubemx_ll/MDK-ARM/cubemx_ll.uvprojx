# Keil uVision project cubemx_ll.uvprojx, settings and files
target cubemx_ll (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L072RBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: cubemx_ll
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32L072xx
  c misc: --C99
  c include: ../Inc;   ../Drivers/STM32L0xx_HAL_Driver/Inc;   ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;   ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;   ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;   ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;   ../Middlewares/Third_Party/FatFs/src;   ../Drivers/CMSIS/Include;  ../Cfg;  ../Src;  ../Lib/piconomix-fwlib/common;  ../Lib/piconomix-fwlib/comms;  ../Lib/piconomix-fwlib/devices/mem;  ../Lib/piconomix-fwlib/utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_spi.c stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_hal_rcc.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_hal_tim_ex.c stm32l0xx_ll_usart.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_i2c_ex.c stm32l0xx_ll_tim.c stm32l0xx_ll_i2c.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_pcd.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_i2c.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc_ex.c stm32l0xx_ll_rtc.c stm32l0xx_ll_rcc.c stm32l0xx_ll_gpio.c stm32l0xx_hal_flash.c stm32l0xx_hal_pwr.c stm32l0xx_ll_adc.c stm32l0xx_hal.c
  group Application/MDK-ARM
    ./: startup_stm32l072xx.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User
    ../Src/: dac.c main.c spi.c gpio.c tim.c usbd_desc.c i2c.c usart.c usb_device.c usbd_cdc_if.c user_diskio.c stm32l0xx_hal_msp.c rtc.c adc.c fatfs.c stm32l0xx_it.c usbd_conf.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l0xx.c
software components: CMSIS:CORE 4.1.0
