# Keil uVision project cubemx_hal.uvprojx, settings and files
target cubemx_hal (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L072RBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: cubemx_hal
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L072xx
  c misc: --C99
  c include: ../Inc;    ../Drivers/STM32L0xx_HAL_Driver/Inc;    ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;    ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;    ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;    ../Middlewares/Third_Party/FatFs/src;    ../Drivers/CMSIS/Include;   ../Cfg;   ../Src;   ../Lib/piconomix-fwlib/common;   ../Lib/piconomix-fwlib/comms;   ../Lib/piconomix-fwlib/devices/mem;   ../Lib/piconomix-fwlib/utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_dac.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_tim.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_cortex.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_i2c.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_pcd.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rtc.c stm32l0xx_hal_uart.c
  group Application/MDK-ARM
    ./: startup_stm32l072xx.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Application/User
    ../Src/: dac.c user_diskio.c spi.c adc.c usart.c usbd_conf.c usbd_desc.c usbd_cdc_if.c usb_device.c stm32l0xx_it.c gpio.c rtc.c fatfs.c i2c.c stm32l0xx_hal_msp.c main.c tim.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l0xx.c
software components: CMSIS:CORE 4.1.0
